# Keil uVision project Intelligent_engineering_card.uvprojx, settings and files
target Intelligent_engineering_card (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L130F8UA HDSC
  pack: HDSC.HC32L130.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uart_int
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\mcu\common;..\source;..\..\..\driver\inc;..\include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l136.s
    ../../../mcu/common/: system_hc32l136.c
  group main
    ../main/: main.c
  group source
    ../source/: led.c uart_deal.c gps.c io_key.c gprs_message.c rgb.c buzzer.c flash_deal.c timer3_deal.c nb_iot_module.c base_time_deal.c rtc_deal.c lpm_deal.c arry_queue.c adc_deal.c pca_deal.c
    ../../../driver/src/: bgr.c
  group driver
    ../../../driver/src/: gpio.c interrupts_hc32l136.c sysctrl.c uart.c wdt.c ddl.c flash.c timer3.c bt.c lpm.c rtc.c adc.c pca.c
  group README
    ../: readme.txt
